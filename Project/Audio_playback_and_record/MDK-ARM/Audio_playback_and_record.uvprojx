# Keil uVision project Audio_playback_and_record.uvprojx, settings and files
target MEDIA_intFALSH (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MEDIA_intFLASH
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, USE_USB_OTG_FS, STM32F4XX,  MEDIA_IntFLASH
  c include: ..\inc;..\..\..\Libraries\CMSIS\ST\STM32F4xx\Include;..\..\..\Libraries\CMSIS\Include;..\..\..\Utilities\Third_Party\fat_fs\inc;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc;..\..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\..\Utilities\STM32F4-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../src/: audio_sample.c main.c stm32f4xx_it.c system_stm32f4xx.c usb_bsp.c usbh_usr.c waveplayer.c waverecorder.c
  group STM32F4-Discovery
    ../../../Utilities/STM32F4-Discovery/: stm32f4_discovery.c stm32f4_discovery_lis302dl.c stm32f4_discovery_audio_codec.c libPDMFilter_Keil.lib
  group STM32F4xx_StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_syscfg.c misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c
  group MDK-ARM
    ../../../Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group STM32_USB_OTG_Driver
    ../../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd_int.c usb_hcd.c
  group STM32_USB_HOST_Library
    ../../../Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_scsi.c usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c
    ../../../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_stdreq.c usbh_core.c usbh_hcs.c usbh_ioreq.c
  group FAT_FS
    ../../../Utilities/Third_Party/fat_fs/src/: ff.c fattime.c
target MEDIA_USB_KEY (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: as above
  output: MEDIA_USB_KEY
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, USE_USB_OTG_FS, STM32F4XX, MEDIA_USB_KEY, __FPU_PRESENT=0
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 4.3.0
